# Keil uVision project tLast51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: tLast51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c PW.c
  group Device
    ./: Timer.c iic.c Uart.c
  group Hardware
    ./: SEG.c KBD.c EEPROM.c ULN2003D.c
